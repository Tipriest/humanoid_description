Commit message: update ly_humanoid.urdf

File: ly_humanoid_description/urdf/ly_humanoid.urdf (robot description, URDF)
Before this commit: robot ly_humanoid, 16 links, 15 joints
Joints:
- joint joint0: origin xyz=5.7543E-05 0.04397 -0.25 rpy=0 0 0 -> xyz=5.7543E-05 0.04397 -1.00 rpy=0 0 0
